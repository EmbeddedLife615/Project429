# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\BSP\STM32F429-Apollo\inc;..\..\Drivers\BSP\Components\inc;..\..\FnucModules\Stm32f429-Apollo;..\..\FnucModules\Stm32f429-Apollo\inc;..\..\FnucModules\Components\inc;..\..\Applications\User\Core\inc;..\..\Applications\User\App\Inc;..\..\Applications\User\App
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User/Core
    ../../Applications/User/Core/src/: main.c stm32f4xx_it.c global_variable.c
  group Application/User/App
    ../../Applications/User/App/: app.c
    ../../Applications/User/App/Src/: app_led.c
  group Application/MDK-ARM
    ../../Applications/MDK-ARM/: startup_stm32f429xx.s
  group FuncModules/Stm32f429-Apollo
    ../../FnucModules/Stm32f429-Apollo/: fml.c
    ../../FnucModules/Stm32f429-Apollo/src/: fml_led.c fml_tick.c
  group Drivers/BSP/Stm32f429-Apollo
    ../../Drivers/BSP/STM32F429-Apollo/src/: stm32f4xx_assert.c bsp.c bsp_led.c bsp_sysclk.c bsp_tick.c
  group Drivers/CMSIS
    ../../Applications/User/Core/src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c
  group Doc
    ../Doc/: Readme.txt
