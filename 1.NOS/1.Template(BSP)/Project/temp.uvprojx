# Keil uVision project temp.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER
  c include: ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\User\app;..\User\app\Inc;..\User\bsp;..\User\bsp\inc;..\User\mid;..\User\mid\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../User/app/: main.c app.c
    ../User/app/Src/: app_led.c
  group Function/FML
    ../User/mid/: fml.c
    ../User/mid/src/: fml_led.c
  group Drivers/BSP
    ../User/bsp/: bsp.c stm32f4xx_it.c stm32f4xx_assert.c system_stm32f4xx.c stm32f4xx_hal_msp.c
    ../User/bsp/src/: bsp_gpio.c bsp_sysclk_cfg.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c
  group Doc
    ../Doc/: Readme.txt
